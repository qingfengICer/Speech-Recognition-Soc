# Keil uVision project CortexM3_VoiceRecognition.uvprojx, settings and files
target CortexM3_VoiceRecognition (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CortexM3_VoiceRecognition +hex
  AfterMake: fromelf.exe --vhx --32x1 --output=.\output\image.hex .\objects\CortexM3_VoiceRecognition.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: ..\..\Programs\App\inc;..\..\Programs\Board\inc;..\..\Programs\Chip\CMSIS;..\..\Programs\Chip\Hal_lib\inc;..\..\Programs\Chip\Startup\inc;..\..\Programs\Function;..\..\Programs\Algorithm\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  link misc: --entry Reset_Handler
  group App
    ../../Programs/App/: debug.c delay.c main.c
  group Board
    ../../Programs/Board/: asio.c
    ../../Programs/Board/inc/: Keyboard.h
  group Hal_lib
    ../../Programs/Chip/Hal_lib/: nvic.c uart.c pdm2pcm.c
  group Startup
    ../../Programs/Chip/Startup/keil/: cnasic_soc.s
  group Function
    ../../Programs/Function/: FunctionTest.c VoiceRecognition.c VoiceTemplateAcquisition.c TemplateSet.h VoiceTemplateLoad.c
  group Algorithm
    ../../Programs/Algorithm/: fft.c VoicePreprocessing.c mfcc.c dtw.c
